# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Start;.\User;.\Library;.\System;.\User\App;.\User\Drivers;.\User\Storage;.\User\Tests
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h
  group System
    ./System/: Delay.c Delay.h system_time.c system_time.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Flash Phase 1
    ./User/: config.h
    ./User/Drivers/: w25q64.c w25q64.h w25q64_port.h
    ./System/: w25q64_port_stm32.c
    ./User/Tests/: flash_test.c flash_test.h
  group Flash Phase 2
    ./User/Storage/: crc32.c crc32.h flash_manager.c flash_manager.h
    ./User/Tests/: flash_manager_test.c flash_manager_test.h
  group Data Logger Phase 3
    ./User/Drivers/: mpu6050.c mpu6050.h mpu6050_port.h
    ./System/: mpu6050_port_stm32.c
    ./User/App/: data_logger.c data_logger.h
    ./User/Tests/: data_logger_test.c data_logger_test.h power_fail_test.c power_fail_test.h
  group Wear Leveling Phase 5
    ./User/Storage/: wear_leveling.c wear_leveling.h
  group UART CLI Phase 7
    ./User/App/: cli.c cli.h
    ./User/Drivers/: uart_port.h
    ./System/: uart_port_stm32.c
  group Benchmark Phase 8
    ./User/App/: flash_benchmark.c flash_benchmark.h
